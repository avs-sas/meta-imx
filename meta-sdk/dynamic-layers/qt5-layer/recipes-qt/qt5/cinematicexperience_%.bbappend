
# Remove dependency on qtgraphicaleffects for sololite
DEPENDS:remove:mx6sl = "qtgraphicaleffects"
RDEPENDS:${PN}:remove_mx6sl = "qtgraphicaleffects-qmlplugins"
